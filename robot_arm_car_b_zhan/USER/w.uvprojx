# Keil uVision project w.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: w +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user;..\fwlib\inc;..\system\delay;..\system\sys;..\system\usart;..\hardware;..\VL53L0X\inc;..\WIT_C_SDK;..\HARDWARE;..\HARDWARE;..\HARDWARE;..\HARDWARE;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: startup_stm32f40_41xxx.s core_cm4.h
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group hardware
    ../HARDWARE/: systick.c key.c oled.c motor.c encoder.c usart2.c pid.c
    ../hardware/: led.c
  group usart
    ../HARDWARE/: usart1.c usart3.c dj.c uart4.c uart5.c usart6.c
  group ctrl
    ../HARDWARE/: motor_ctrl.c ctrl.c schedule.c
  group system
    ../system/sys/: sys.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group wit_c_sdk
    ../WIT_C_SDK/: wit_c_sdk.c
